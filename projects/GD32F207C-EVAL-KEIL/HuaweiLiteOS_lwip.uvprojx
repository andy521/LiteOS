# Keil uVision project HuaweiLiteOS_lwip.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F207VC GigaDevice
  pack: Keil.GD32F2xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32f190R8T6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m3;..\..\kernel\link\keil;..\..\platform\GD32F207C-EVAL;..\..\example\include;..\..\GD32F207_Library;..\..\GD32F207_Library\CMSIS;..\..\GD32F207_Library\GD32F20x_standard_peripheral\Include;..\..\GD32F207_Library\CMSIS\GD\GD32F20x\Include;..\..\components\lwip-2.0.2\include;..\..\components\lwip-2.0.2\include\arch;..\..\platform\GD32F207C-EVAL\lwip-port;..\..\platform\GD32F207C-EVAL\lwip-port\arch;..\..\platform\GD32F207C-EVAL\lwip-port\netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/cm3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group platform/GD32F207C
    ../../platform/GD32F207C-EVAL/: los_bsp_adapter.c los_bsp_key.c los_bsp_uart.c los_bsp_led.c los_bsp_lwip.c los_bsp_eth.c
  group startup
    ../../platform/GD32F207C-EVAL/: los_startup_keil.s
  group user
    ../../user/: main.c
  group library
    ../../GD32F207_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_cau.c gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
    ../../GD32F207_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group lwip
    ../../components/lwip-2.0.2/api/: netbuf.c api_lib.c api_msg.c err.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/lwip-2.0.2/core/: def.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/lwip-2.0.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../platform/GD32F207C-EVAL/lwip-port/netif/: ethernetif.c
    ../../components/lwip-2.0.2/arch/: sys_arch.c
    ../../components/lwip-2.0.2/netif/: ethernet.c
