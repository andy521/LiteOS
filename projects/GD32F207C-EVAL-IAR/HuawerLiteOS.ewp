# IAR project HuawerLiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F20xxC GD GD32F20xxC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F20X_CL
  ICCARM.CCDiagSuppress: Pa050,Pe068,Pe193,Pe1813,Pe181
  ICCARM.CCIncludePath2: ..\..\example\include; ..\..\kernel\base\include; ..\..\kernel\base\core; ..\..\kernel\base\ipc; ..\..\kernel\base\mem; ..\..\kernel\cmsis; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m3; ..\..\kernel\include; ..\..\kernel\link\iar; ..\..\platform\GD32F207C-EVAL; ..\..\platform\GD32F207C-EVAL\GD32F207_Library; ..\..\platform\GD32F207C-EVAL\GD32F207_Library\CMSIS; ..\..\platform\GD32F207C-EVAL\GD32F207_Library\CMSIS\GD\GD32F20x\Include; ..\..\platform\GD32F207C-EVAL\GD32F207_Library\GD32F20x_standard_peripheral\Include; ..\..\components\lwip-2.0.2\include; ..\..\components\lwip-2.0.2\include\arch; ..\..\platform\GD32F207C-EVAL\lwip-port; ..\..\platform\GD32F207C-EVAL\lwip-port\arch; ..\..\platform\GD32F207C-EVAL\lwip-port\netif; ..\..\components\lwip-2.0.2\apps\httpserver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\kernel\base\include
  OBJCOPY.OOCOutputFile: HuawerLiteOS.srec
  ILINK.IlinkOutputFile: HuawerLiteOS.out
  ILINK.IlinkIcfFile: GD32F20xxC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
    ../../platform/GD32F207C-EVAL/lwip-port/: lwipopts.h
  group Huawei_LiteOS/cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/library
    ../../platform/GD32F207C-EVAL/GD32F207_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
    ../../platform/GD32F207C-EVAL/GD32F207_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Huawei_LiteOS/lwip
    ../../components/lwip-2.0.2/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/lwip-2.0.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/lwip-2.0.2/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/lwip-2.0.2/netif/: ethernet.c
    ../../platform/GD32F207C-EVAL/lwip-port/netif/: ethernetif.c
    ../../components/lwip-2.0.2/arch/: sys_arch.c
  group Huawei_LiteOS/platform/GD32F207C
    ../../platform/GD32F207C-EVAL/: los_bsp_adapter.c los_bsp_eth.c los_bsp_key.c los_bsp_led.c los_bsp_lwip.c los_bsp_uart.c
  group Huawei_LiteOS/startup
    ../../platform/GD32F207C-EVAL/: los_startup_iar.s
  group Huawei_LiteOS/user
    ../../components/lwip-2.0.2/apps/httpserver/: httpserver-netconn.c httpserver-netconn.h
    ../../user/: main.c
    ../../components/lwip-2.0.2/apps/mqtt/: mqtt.c
    ../../components/lwip-2.0.2/apps/ping/: ping.c
