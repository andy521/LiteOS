# IAR project HuaweiLiteOS_lwip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CR600 CLOUDER CR600
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m0; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\CS6X00; ..\..\platform\CS6X00\library\include; ..\..\components\lwip-2.0.2\include; ..\..\components\lwip-2.0.2\include\lwip\apps; ..\..\platform\CS6X00\lwip-port; ..\..\platform\CS6X00\lwip-port\netif; ..\..\platform\CS6X00\lwip-port\arch; ..\..\platform\CS6X00\devices
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS_stm32f429.bin
  ILINK.IlinkOutputFile: cr600.out
  ILINK.IlinkIcfFile: clouder600_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m0
    ../../kernel/cpu/arm/cortex-m0/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/library
    ../../platform/CS6X00/library/: driver.a
  group Huawei_LiteOS/lwip
    ../../components/lwip-2.0.2/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/lwip-2.0.2/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/lwip-2.0.2/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/lwip-2.0.2/netif/: ethernet.c
    ../../platform/CS6X00/lwip-port/netif/: ethernetif.c
    ../../components/lwip-2.0.2/arch/: sys_arch.c
  group Huawei_LiteOS/platform/CS6X00
    ../../platform/CS6X00/: los_bsp_adapter.c los_bsp_eth.c los_bsp_key.c los_bsp_led.c los_bsp_lwip.c los_bsp_misc.c los_bsp_uart.c
  group Huawei_LiteOS/platform/CS6X00/app
    ../../platform/CS6X00/app/: mqtt_client.c
  group Huawei_LiteOS/platform/CS6X00/devices
    ../../platform/CS6X00/devices/: KSZ8041.c LM75A.c
  group Huawei_LiteOS/startup
    ../../platform/CS6X00/: los_startup_iar.s
  group Huawei_LiteOS/user
    ../../components/lwip-2.0.2/apps/httpserver/: httpserver-netconn.c
    ../../user/: main.c
    ../../components/lwip-2.0.2/apps/mqtt/: mqtt.c
